File: hw/sch_pcb/fuel_gauge.kicad_sch (KiCad schematic)
At the start: 39 parts

Commit message: Pridano schema menice ze solarniho clanku
Other:
- moved on the sheet: C?, D?, J?, R?, SW?, U?
